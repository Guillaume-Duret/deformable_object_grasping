Commit message: fix mass props for vase

File: examples/vase/vase.urdf (robot description, URDF)
Before this commit: robot root, 1 links, 0 joints
Links:
- link link_rectangle: mass 3.45E-05 -> 0.0131
